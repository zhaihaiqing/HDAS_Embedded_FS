# Keil uVision project HDAS_V1.0.0_Embedded.uvprojx, settings and files
target HDAS_V1.0.0_Embedded (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32H743XIHx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.7.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2407FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: HDAS_V1.0.0_Embedded +hex
  c flags: Optim=3 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32H743xx
  c include: ../Core/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include;..\FATFS\Target;..\FATFS\App;..\Middlewares\Third_Party\FatFs\src;..\RTT_Nano;..\RTT_Nano\shell;..\RTT_Nano\kernal;..\RTT_Nano\include;..\Middlewares\ST\STM32_USB_Device_Library\Class\MSC\Inc;..\Middlewares\ST\STM32_USB_Device_Library\Core\Inc;..\USB_DEVICE\App;..\USB_DEVICE\Target
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  group Application/User/Core
    ../Core/Src/: main.c hdas_thread.c gpio.c adc.c sdmmc_fatfs.c sdmmc_test.c sdmmc.c usart.c stm32h7xx_it.c stm32h7xx_hal_msp.c i2c.c i2c_at24.c dma.c fmc.c FMC_TIM_AD7606.c tim.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_adc.c stm32h7xx_hal_adc_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_cortex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_ll_sdmmc.c stm32h7xx_ll_delayblock.c stm32h7xx_hal_sd.c stm32h7xx_hal_sd_ex.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_ll_fmc.c stm32h7xx_hal_sram.c stm32h7xx_hal_pcd.c stm32h7xx_hal_pcd_ex.c stm32h7xx_ll_usb.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h7xx.c
    ./: startup_stm32h743xx.s
    ./: armlib_lock_glue.c
  group Application/User/FATFS/Target
    ../FATFS/Target/: bsp_driver_sd.c sd_diskio.c
  group Middlewares/FatFs
    ../FATFS/App/: fatfs.c
    ../FATFS/Target/: ffconf.h
    ../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
    ../Middlewares/Third_Party/FatFs/src/option/: cc936.c syscall.c
  group Application/User/USB_DEVICE/App
    ../USB_DEVICE/Target/: usbd_conf.c
    ../USB_DEVICE/App/: usb_device.c usbd_storage_if.c usbd_desc.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/MSC/Src/: usbd_msc.c usbd_msc_bot.c usbd_msc_data.c usbd_msc_scsi.c
  group RTT-Nano
    ../RTT_Nano/: board.c rtconfig.h
    ../RTT_Nano/shell/: cmd.c msh.c shell.c
    ../RTT_Nano/kernal/: clock.c components.c context_rvds.S cpuport.c idle.c ipc.c irq.c kservice.c mem.c object.c scheduler.c thread.c timer.c
software components: CMSIS:CORE 5.4.0
